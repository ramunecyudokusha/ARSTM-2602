# Repository ramunecyudokusha/ARSTM-2602

## KiCad design ARSTM2602.kicad_pcb

Parts:
C1, C9: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5, C7: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 4.7uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C11: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 22μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: D_Shockley; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3, J5, J7, J8: Conn_01x03_Pin; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
J2, J4, J6: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9, J10, J11: Conn_01x02_Socket; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J12: Conn_ST_STDC14; PinHeader_2x07_P1.27mm_Vertical
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: STM32G431RBTx; LQFP-64_10x10mm_P0.5mm
U2: BD33FC0FP; TO-252-2

Connections:
+3.3V: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.2, C11.1, C12.1, D1.2 (A), J12.3 (VCC), U1.1 (VBAT), U1.16 (VDD), U1.28 (VREF+), U1.29 (VDDA), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.3 (VO); also elsewhere on the board
+7.5V: C10.1, D1.1 (K), J11.2, U2.1 (VCC); also elsewhere on the board
+12V: J1.1, J2.1, J9.2
+24V: J10.2; also elsewhere on the board
/Si1: U1.44 (PA10); also elsewhere on the board
/Si2: U1.43 (PA9); also elsewhere on the board
/Si3: U1.42 (PA8); also elsewhere on the board
/Si4: U1.41 (PC9); also elsewhere on the board
/Si5: U1.40 (PC8); also elsewhere on the board
/Tim4ch1: J1.3, U1.59 (PB6)
/Tim4ch2: J2.3, U1.60 (PB7)
/emergency_sw: U1.3 (PC14)
/spi_cs_2: U1.34 (PB12); also elsewhere on the board
/spi_cs_3: U1.51 (PA15); also elsewhere on the board
/spi_int_2: U1.38 (PC6); also elsewhere on the board
/spi_int_3: U1.55 (PD2); also elsewhere on the board
/spi_miso_2: U1.36 (PB14); also elsewhere on the board
/spi_miso_3: U1.53 (PC11); also elsewhere on the board
/spi_mosi_2: U1.37 (PB15); also elsewhere on the board
/spi_mosi_3: U1.54 (PC12); also elsewhere on the board
/spi_sclk_2: U1.35 (PB13); also elsewhere on the board
/spi_sclk_3: U1.52 (PC10); also elsewhere on the board
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, J1.2, J2.2, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J11.1, J12.5 (GND), J12.7 (GND), SW1.2, U1.15 (VSS), U1.27 (VSSA), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND); also elsewhere on the board
GND1: J10.1; also elsewhere on the board
Tim1ch1: J3.2, U1.8 (PC0)
Tim1ch2: J3.3, U1.9 (PC1)
Tim1ch3: J4.2, U1.10 (PC2)
Tim1ch4: J4.3, U1.11 (PC3)
Tim2ch1: J5.2, U1.12 (PA0)
Tim2ch2: J5.3, U1.13 (PA1)
Tim2ch3: J6.2, U1.14 (PA2)
Tim2ch4: J6.3, U1.17 (PA3)
Tim3ch1: J7.3, U1.21 (PA7)
Tim3ch2: J7.2, U1.20 (PA6)
Tim3ch3: J8.3, U1.25 (PB1)
Tim3ch4: J8.2, U1.24 (PB0)
can1_rx: U1.62 (PB9); also elsewhere on the board
can1_tx: U1.61 (PB8); also elsewhere on the board
jtdi: J12.10 (JTDI/NC)
nrst: SW1.1, U1.7 (PG10)
swclk: J12.6 (JCLK/SWCLK), U1.50 (PA14)
swdio: J12.4 (JTMS/SWDIO), U1.49 (PA13)
swo: J12.8 (JTDO/SWO)
trst: J12.12 (~RST)
uart2-rx: J12.13 (VCP_RX), U1.57 (PB4)
uart2-tx: J12.14 (VCP_TX), U1.58 (PB5)

Notes on the sheet:
デバッグ系
リセット用スイッチ
servox2

Parts:
C13: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 0.1μF; C_0603_1608Metric
C15: 22μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C16, C17: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C18: 22uf; CP_Radial_D5.0mm_P2.00mm
D2: D_Shockley; D_SOD-323_HandSoldering
J13: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_Palconn_UTC16-G
J14: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP1: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5: 10k; R_0805_2012Metric
SW2, SW3: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U3: ESP32-C3-WROOM-02
U4: BD33FC0FP; TO-252-2

Connections:
+3V3: C14.1, C15.1, C17.1, C18.1, D2.2 (A), R3.2, R4.2, R5.2, U3.1 (3V3), U4.3 (VO); also elsewhere on the board
+5V: J13.A4 (VBUS), J13.A9 (VBUS), J13.B4 (VBUS), J13.B9 (VBUS), JP1.1 (A); also elsewhere on the board
+7.5V: JP1.3 (B); also elsewhere on the board
/ESP/emergency_sw: J14.2, U3.10 (IO10)
/ESP/esp_d+: J13.A6 (D+), J13.B6 (D+), U3.14 (IO19)
/ESP/esp_d-: J13.A7 (D-), J13.B7 (D-), U3.13 (IO18)
/spi_cs_3: U3.6 (IO7); also elsewhere on the board
/spi_int_3: U3.15 (IO3); also elsewhere on the board
/spi_miso_3: U3.4 (IO5); also elsewhere on the board
/spi_mosi_3: U3.3 (IO4); also elsewhere on the board
/spi_sclk_3: U3.5 (IO6); also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, J13.A1 (GND), J13.A12 (GND), J13.B1 (GND), J13.B12 (GND), J13.SH (SHIELD), J14.1, R1.2, R2.2, SW2.1, SW3.1, U3.9 (GND), U3.19 (GND), U4.2 (GND); also elsewhere on the board
unnamed: C16.1, D2.1 (K), JP1.2 (C), U4.1 (VCC)
unnamed: J13.A5 (CC1), R1.1
unnamed: J13.B5 (CC2), R2.1
unnamed: C13.1, R3.1, SW2.2, U3.2 (EN)
unnamed: R4.1, U3.16 (IO2)
unnamed: R5.1, U3.7 (IO8)
unnamed: SW3.2, U3.8 (IO9)

Parts of its further copies:
C21: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22: 0.1μF; C_0603_1608Metric
C23: 22μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C24, C25: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26: 22uf; CP_Radial_D5.0mm_P2.00mm
D3: D_Shockley; D_SOD-323_HandSoldering
J17: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_Palconn_UTC16-G
J18: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP2: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
R7, R8: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R11: 10k; R_0805_2012Metric
SW5, SW6: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U6: ESP32-C3-WROOM-02
U7: BD33FC0FP; TO-252-2

Connections of its further copies:
+3V3: C22.1, C23.1, C25.1, C26.1, D3.2 (A), R9.2, R10.2, R11.2, U6.1 (3V3), U7.3 (VO); also elsewhere on the board
+5V: J17.A4 (VBUS), J17.A9 (VBUS), J17.B4 (VBUS), J17.B9 (VBUS), JP2.1 (A); also elsewhere on the board
+7.5V: JP2.3 (B); also elsewhere on the board
/ESP1/emergency_sw: J18.2, U6.10 (IO10)
/ESP1/esp_d+: J17.A6 (D+), J17.B6 (D+), U6.14 (IO19)
/ESP1/esp_d-: J17.A7 (D-), J17.B7 (D-), U6.13 (IO18)
/spi_cs_2: U6.6 (IO7); also elsewhere on the board
/spi_int_2: U6.15 (IO3); also elsewhere on the board
/spi_miso_2: U6.4 (IO5); also elsewhere on the board
/spi_mosi_2: U6.3 (IO4); also elsewhere on the board
/spi_sclk_2: U6.5 (IO6); also elsewhere on the board
GND: C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, J17.A1 (GND), J17.A12 (GND), J17.B1 (GND), J17.B12 (GND), J17.SH (SHIELD), J18.1, R7.2, R8.2, SW5.1, SW6.1, U6.9 (GND), U6.19 (GND), U7.2 (GND); also elsewhere on the board
unnamed: C24.1, D3.1 (K), JP2.2 (C), U7.1 (VCC)
unnamed: J17.A5 (CC1), R7.1
unnamed: J17.B5 (CC2), R8.1
unnamed: C21.1, R9.1, SW5.2, U6.2 (EN)
unnamed: R10.1, U6.16 (IO2)
unnamed: R11.1, U6.7 (IO8)
unnamed: SW6.2, U6.8 (IO9)

Notes on the sheet:
boot sw

Parts:
D4: D; D_SOD-323F
J19: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
Q1: Q_NMOS_GSD; SOT-23_Handsoldering
R12: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14: 10k; R_0805_2012Metric
U8: TLP785; DIP-4_W7.62mm

Connections:
+24V: D4.1 (K), J19.1, U8.4; also elsewhere on the board
/Si1: R12.2; also elsewhere on the board
GND: U8.2; also elsewhere on the board
GND1: Q1.2 (S), R14.2; also elsewhere on the board
unnamed: D4.2 (A), J19.2, Q1.3 (D)
unnamed: Q1.1 (G), R13.2, R14.1
unnamed: R12.1, U8.1
unnamed: R13.1, U8.3

Parts of its further copies:
D5, D6, D7, D8: D; D_SOD-323F
J20, J21, J22, J23: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
Q2, Q3, Q4, Q5: Q_NMOS_GSD; SOT-23_Handsoldering
R15, R18, R21, R24: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17, R19, R20, R22, R23, R25, R26: 10k; R_0805_2012Metric
U9, U10, U11, U12: TLP785; DIP-4_W7.62mm

Connections of its further copies:
+24V: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J20.1, J21.1, J22.1, J23.1, U9.4, U10.4, U11.4, U12.4; also elsewhere on the board
/Si2: R15.2; also elsewhere on the board
/Si3: R18.2; also elsewhere on the board
/Si4: R21.2; also elsewhere on the board
/Si5: R24.2; also elsewhere on the board
GND: U9.2, U10.2, U11.2, U12.2; also elsewhere on the board
GND1: Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R17.2, R20.2, R23.2, R26.2; also elsewhere on the board
unnamed: D5.2 (A), J20.2, Q2.3 (D)
unnamed: D6.2 (A), J21.2, Q3.3 (D)
unnamed: D7.2 (A), J22.2, Q4.3 (D)
unnamed: D8.2 (A), J23.2, Q5.3 (D)
unnamed: Q2.1 (G), R16.2, R17.1
unnamed: Q3.1 (G), R19.2, R20.1
unnamed: Q4.1 (G), R22.2, R23.1
unnamed: Q5.1 (G), R25.2, R26.1
unnamed: R15.1, U9.1
unnamed: R16.1, U9.3
unnamed: R18.1, U10.1
unnamed: R19.1, U10.3
unnamed: R21.1, U11.1
unnamed: R22.1, U11.3
unnamed: R24.1, U12.1
unnamed: R25.1, U12.3

Notes on the sheet:
Vgs= 12V Vds= 24V
24Vを12Vに分圧してゲートをたたく
Vsi = 3.3V

Parts:
C19: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J15, J16: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW4: SW_DPDT_x2; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
U5: TCAN3414DRBR; XCVR_TCAN3414DRBR; PARTREV A

Connections:
+3.3V: C19.2, C20.2, U5.3 (VCC); also elsewhere on the board
/can1/can+: J15.2, J16.2, R6.1, U5.7 (CANH)
/can1/can-: J15.1, J16.1, SW4.2 (B), U5.6 (CANL)
/can1/canR: R6.2, SW4.1 (A)
GND: C19.1, C20.1, U5.2 (GND), U5.5 (SHDN), U5.8 (STB), U5.9 (EXP); also elsewhere on the board
can1_rx: U5.4 (RXD); also elsewhere on the board
can1_tx: U5.1 (TXD); also elsewhere on the board

Board: 2 copper layers, 100.0 x 100.0 mm, 112 parts (58 on the bottom side), 87 nets.

File production/arstm2602_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C13, C21, C9",0603,4,1uf,
"C10, C11, C16, C17, C24, C25",0805,6,4.7μF,
"C12, C15, C23",0805,3,22μF,
"C14, C22",0603,2,0.1μF,
"C18, C26",CP_Radial_D5.0mm_P2.00mm,2,22uf,
"C19, C2, C3, C4, C5, C7, C8",0603,7,0.1uF,
C20,0603,1,4.7uF,
C6,0805,1,4.7uf,
"D1, D2, D3",D_SOD-323_HandSoldering,3,D_Shockley,
"D4, D5, D6, D7, D8",D_SOD-323F,5,D,
"J1, J3, J5, J7, J8",JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal,5,Conn_01x03_Pin,
"J10, J11, J9",AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,3,Conn_01x02_Socket,
J12,PinHeader_2x07_P1.27mm_Vertical,1,Conn_ST_STDC14,
"J13, J17",USB_C_Receptacle_Palconn_UTC16-G,2,USB_C_Receptacle_USB2.0_14P,
"J14, J18",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,2,Conn_01x02_Socket,
"J15, J16, J19, J20, J21, J22, J23",JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal,7,Conn_01x02_Socket,
"J2, J4, J6",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,3,Conn_01x03_Pin,
"Q1, Q2, Q3, Q4, Q5",SOT-23_Handsoldering,5,Q_NMOS_GSD,
"R1, R2, R7, R8",0603,4,5.1k,
"R10, R11, R13, R14, R16, R17, R19, R20, R22, R23, R25, R26, R3, R4, R5, R9",0805,16,10k,
"R12, R15, R18, R21, R24",0603,5,330,
R6,0603,1,120,
"SW1, SW2, SW3, SW5, SW6",SW_Push_SPST_NO_Alps_SKRK,5,SW_Push,
SW4,SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm,1,SW_DPDT_x2,
U1,LQFP-64_10x10mm_P0.5mm,1,STM32G431RBTx,
"U10, U11, U12, U8, U9",DIP-4_W7.62mm,5,TLP785,
"U2, U4, U7",TO-252-2,3,BD33FC0FP,
"U3, U6",ESP32-C3-WROOM-02,2,ESP32-C3-WROOM-02,
U5,XCVR_TCAN3414DRBR,1,TCAN3414DRBR,

## Commit log (part)

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2026-04-26 start project
2026-05-07 aaa
    gitdesktop test
2026-05-08 回路図を書き換えた
    マイコンを載せ替えただけ
2026-05-11 回路図をこぴった
2026-05-12 canモジュールを増やした
    電源供給方法をいろいろ考えついたから頑張る()
2026-05-17 canモジュールの置き換え
    tcan3414に置き換えた
2026-05-24 サブマイコンx2を配置
    ESPとラズパイを置いた
    ラズパイはまだ途中
2026-06-16 一部回路図変更と部品配置
2026-06-21 電磁弁用回路の増設
2026-06-25 完成(電磁弁制御,モーター出力追加済み)
2026-06-28 サーボときんていをつけ忘れていたので回路図に追加(部品配置に悩んでる
2026-06-29 サーボ系ときんてい系の部品の配置と配線
